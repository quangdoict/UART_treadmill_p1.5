<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Sport1_New_UART_lib.ewp</path>
    </project>
    <batchBuild />
</workspace>
